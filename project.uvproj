# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f2xx.s LCD_TEST.c Display.c Display.h Global.h Inputs.c Inputs.h Text.c Text.h Time.c Time.h
    ./board_files/: JOY.c LED.c Serial.c JOY.h LED.h Serial.h GLCD.h GLCD_16bitIF_STM32F2xx.c I2C.h I2C_STM32F2xx.c system_stm32f2xx.c KBD.c KBD.h sram.c sram.h
  group RTX Config
    ./: RTX_Conf_CM.c
